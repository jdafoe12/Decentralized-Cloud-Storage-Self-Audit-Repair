# IAR project NSAC_HIFTL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC3131 NXP LPC3131
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCDefines: BOOT_LEVEL_2
  ICCARM.CCIncludePath2: ..\..; ..\..\sys\lpc313x\bsp; ..\..\sys\lpc313x\csp; ..\..\sys\lpc313x\lib; ..\..\sys\lpc313x\usb
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: onfm_fresh.bin
  ILINK.IlinkOutputFile: onfm.out
  ILINK.IlinkIcfFile: C:\Users\bchen-adm\Desktop\nsac-hiftl-dc\sys\lpc313x\config\LPC313x_iRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..; ..\..\sys\lpc313x\bsp; ..\..\sys\lpc313x\csp; ..\..\sys\lpc313x\lib; ..\..\sys\lpc313x\usb; ..\..\core\; ..\..\core\matrix; ..\..\core\gladman; ..\..\core\polar\include
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: onfm_fresh_Re.bin
  ILINK.IlinkIcfFile: C:\Users\Sonam Vinay Jain\NSAC_Lab\Secure Deletion\Fresh\sys\lpc313x\config\LPC313x_iRAM.icf
  group core
    ../../: cfg.h
    ../../core/: onfm.c
  group core/buf
    ../../core/buf/: buf_api.c
  group core/ftl
    ../../core/ftl/: aes.c aes.h ecdh.c ecdh.h ftl_api.c ftl_bdt.c ftl_data.c ftl_hdi.c ftl_inc.h ftl_pmt.c ftl_root.c hmac.h hmac_sha1.c init.c init.h prp.c prp.h sha.h sha1.c
  group core/mtd
    ../../core/mtd/: mtd_api.c
  group core/ubi
    ../../core/ubi/: ubi_anchor.c ubi_api.c ubi_area.c ubi_inc.h ubi_index.c ubi_table.c
  group lpc313x
    ../../sys/lpc313x/: main.c
  group lpc313x/bsp
    ../../sys/lpc313x/bsp/: arm926ej_cp15_drv.c cstartup.s spinor_bootloader.c vectors.s
  group lpc313x/csp
    ../../sys/lpc313x/csp/: drv_cgu.c drv_intc.c drv_nand.c drv_spi.c drv_spinor.c drv_uart.c
  group lpc313x/lib
    ../../sys/lpc313x/lib/: lpc313x_cgu_driver.c lpc313x_timer_driver.c lpc313x_usbdcd.c
  group lpc313x/usb
    ../../sys/lpc313x/usb/: mscuser.c usbcore.c usbdesc.c
